# Keil uVision project rak-prj.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32WLE5CCUx STMicroelectronics
  pack: Keil.STM32WLxx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20008000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") DSP CLOCK(12000000) ELITTLE
  output: rak-prj +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32WLE5xx, USE_HAL_DRIVER
  c include: .\Inc;.\Drivers\STM32WLxx_HAL_Driver\Inc;.\Drivers\CMSIS\Device\ST\STM32WLxx\Include;.\Drivers\CMSIS\Core\Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20008000 size 0x8000
  group Application
    ./Src/: hw_init.c lora_p2p.c main_master.c uart_debug.c
  group HAL_Driver
    ./Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal.c stm32wlxx_hal_cortex.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_dma.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_uart.c stm32wlxx_hal_uart_ex.c stm32wlxx_hal_subghz.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c
  group CMSIS
    ./Drivers/CMSIS/Device/ST/STM32WLxx/: system_stm32wlxx.c startup_stm32wle5xx_keil.s
